## board/Seagate/nas440/Kconfig
```kconfig
if TARGET_NAS440

config SYS_BOARD
	default "nas440"

config SYS_VENDOR
	default "Seagate"

config SYS_CONFIG_NAME
	default "nas440"

endif
```
